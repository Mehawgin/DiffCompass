# Keil uVision project lcd_test.uvprojx, settings and files
target QD_LCD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LCD_TEST +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\APPLICATION;..\CMSIS\Include;..\HARDWARE\LCD;..\HARDWARE\SPI;..\SYSTEM\delay;..\SYSTEM\sys;..\USER;..\CMSIS\STM32F4xx\Include;..\STM32F4xx_HAL_Driver\Inc;..\STM32F4xx_HAL_Driver\Inc\Legacy
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../CMSIS/STM32F4xx/Source/: startup_stm32f407xx.s
  group USER
    ../USER/: main.c stm32f4xx_it.c
    ../CMSIS/STM32F4xx/Source/: system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
  group STM32F4xx_HAL_Driver
    ../STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_spi.c
  group HARDWARE
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SPI/: SPI.c
  group APPLICATION
    ../APPLICATION/: GUI.c test.c
